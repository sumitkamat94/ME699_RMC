Commit message: work

File: julia/odes/10dofRobot.urdf (robot description, URDF)
Before this commit: robot Robot1, 13 links, 12 joints
Joints:
- joint eef_left: origin xyz=0 0 -1.25 rpy=0 0 0 -> xyz=0 0 -2.5 rpy=0 0 0
- joint eef_right: origin xyz=0 0 -1.25 rpy=0 0 0 -> xyz=0 0 -2.5 rpy=0 0 0
